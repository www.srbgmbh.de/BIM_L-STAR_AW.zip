Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 98dd9c38-b9dc-4974-b079-94921753d38f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: L-STAR AW-R.ifc
Time: 2024-06-28T09:26:52+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: L-STAR AW-R:L-STAR AW-R - 140 lm - Einzelbatterie, L-STAR AW-R:L-STAR AW-R - 140 lm - Einzelbatterie:2518112
In: Default
Type - Material: Vorgabe(1)
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: L-STAR AW-R - 140 lm - Einzelbatterie; sets with these values: 2
